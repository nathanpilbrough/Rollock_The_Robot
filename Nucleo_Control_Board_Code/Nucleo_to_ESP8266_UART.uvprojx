# Keil uVision project Nucleo_to_ESP8266_UART.uvprojx, settings and files
target Nucleo_to_ESP8266_UART (ARM-ADS)
  device: STM32F746ZGTx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.3.0
  cpu: IROM(0x08000000,0x100000) IROM2(0x00200000,0x100000) IRAM(0x20010000,0x40000) IRAM2(0x20000000,0x10000) CPUTYPE("Cortex-M7") FPU3(SFPU) CLOCK(8000000) ELITTLE
  output: Nucleo_to_ESP8266_UART
  c flags: Optim=2 uC99=1
  c misc: -DTARGET_STM32F746 -DDEVICE_SLEEP=1 -DTOOLCHAIN_object -DTOOLCHAIN_ARM_STD -DDEVICE_RTC=1 --split_sections -DTARGET_STM32F7 -D__ASSERT_MSG -DTARGET_RELEASE --no_rtti -Otime -DDEVICE_PORTINOUT=1 -DDEVICE_SPISLAVE=1 -DTARGET_FF_ARDUINO -c -DTARGET_RTOS_M4_M7 -O3 -DDEVICE_CAN=1 -DDEVICE_PORTOUT=1 -DDEVICE_STDIO_MESSAGES=1 -DDEVICE_ANALOGOUT=1 -DFEATURE_IPV4=1 -DARM_MATH_CM7 --cpu=Cortex-M7.fp.sp -DTARGET_LIKE_CORTEX_M7 -DDEVICE_PORTIN=1 -DTARGET_CORTEX_M -DDEVICE_I2C=1 --preinclude=mbed_config.h -DTARGET_STM -DTOOLCHAIN_ARM -DDEVICE_INTERRUPTIN=1 -DDEVICE_ANALOGIN=1 --no_depend_system_headers -DTARGET_UVISOR_UNSUPPORTED --md -DDEVICE_PWMOUT=1 -DTARGET_LIKE_MBED --gnu -DMBED_BUILD_TIMESTAMP=1481267809.61 --apcs=interwork -DDEVICE_SPI=1 -D__MBED__=1 -DTARGET_NUCLEO_F746ZG -DMBEDTLS_ENTROPY_HARDWARE_ALT -D__CORTEX_M7 -DTARGET_M7 -DDEVICE_SERIAL=1 -D__FPU_PRESENT=1 -DDEVICE_I2CSLAVE=1 -D__CMSIS_RTOS -DTARGET_STM32F746ZG -D__MBED_CMSIS_RTOS_CM
  c include: .; mbed/.; mbed/TARGET_NUCLEO_F746ZG; mbed/TARGET_NUCLEO_F746ZG/TARGET_STM; mbed/TARGET_NUCLEO_F746ZG/TARGET_STM/TARGET_STM32F7; mbed/TARGET_NUCLEO_F746ZG/TARGET_STM/TARGET_STM32F7/device; mbed/TARGET_NUCLEO_F746ZG/TOOLCHAIN_ARM_STD; mbed/drivers; mbed/hal; mbed/platform;
  asm misc: --cpreproc --cpreproc_opts=-D__ASSERT_MSG,-DMBEDTLS_ENTROPY_HARDWARE_ALT,-D__FPU_PRESENT=1,-DARM_MATH_CM7,-D__CMSIS_RTOS,-D__CORTEX_M7,-D__MBED_CMSIS_RTOS_CM
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  scatter file: mbed/TARGET_NUCLEO_F746ZG/TOOLCHAIN_ARM_STD/stm32f746zg.sct
  group Nucleo_to_ESP8266_UART
    ./: computation.cpp main.cpp mbed_config.h Rollock.h waypoints.cpp
  group TARGET_NUCLEO_F746ZG
    mbed/TARGET_NUCLEO_F746ZG/: arm_common_tables.h arm_const_structs.h arm_math.h core_ca9.h core_ca_mmu.h core_caFunc.h core_caInstr.h core_cm0.h core_cm0plus.h core_cm3.h core_cm4.h core_cm4_simd.h core_cm7.h core_cmFunc.h core_cmInstr.h core_cmSecureAccess.h core_cmSimd.h core_sc000.h core_sc300.h
  group TARGET_STM
    mbed/TARGET_NUCLEO_F746ZG/TARGET_STM/: mbed_rtx.h
  group TARGET_STM32F7
    mbed/TARGET_NUCLEO_F746ZG/TARGET_STM/TARGET_STM32F7/: common_objects.h device.h gpio_object.h PeripheralPins.h rtc_api_hal.h
  group TOOLCHAIN_ARM_STD
    mbed/TARGET_NUCLEO_F746ZG/TOOLCHAIN_ARM_STD/: analogin_api.o analogout_api.o can_api.o cmsis_nvic.o gpio_api.o gpio_irq_api.o hal_tick.o i2c_api.o lp_ticker.o mbed.ar mbed_board.o mbed_overrides.o PeripheralPins.o pinmap.o port_api.o pwmout_api.o retarget.o rtc_api.o serial_api.o sleep.o spi_api.o startup_stm32f746zg.o stm32f7xx_hal.o stm32f7xx_hal_adc.o stm32f7xx_hal_adc_ex.o stm32f7xx_hal_can.o stm32f7xx_hal_cec.o stm32f7xx_hal_cortex.o stm32f7xx_hal_crc.o stm32f7xx_hal_crc_ex.o stm32f7xx_hal_cryp.o stm32f7xx_hal_cryp_ex.o stm32f7xx_hal_dac.o stm32f7xx_hal_dac_ex.o stm32f7xx_hal_dcmi.o stm32f7xx_hal_dcmi_ex.o stm32f7xx_hal_dfsdm.o stm32f7xx_hal_dma.o stm32f7xx_hal_dma2d.o stm32f7xx_hal_dma_ex.o stm32f7xx_hal_dsi.o stm32f7xx_hal_eth.o stm32f7xx_hal_flash.o stm32f7xx_hal_flash_ex.o stm32f7xx_hal_gpio.o stm32f7xx_hal_hash.o stm32f7xx_hal_hash_ex.o stm32f7xx_hal_hcd.o stm32f7xx_hal_i2c.o stm32f7xx_hal_i2c_ex.o stm32f7xx_hal_i2s.o stm32f7xx_hal_irda.o stm32f7xx_hal_iwdg.o stm32f7xx_hal_jpeg.o stm32f7xx_hal_lptim.o stm32f7xx_hal_ltdc.o stm32f7xx_hal_ltdc_ex.o stm32f7xx_hal_mdios.o stm32f7xx_hal_nand.o stm32f7xx_hal_nor.o stm32f7xx_hal_pcd.o stm32f7xx_hal_pcd_ex.o stm32f7xx_hal_pwr.o stm32f7xx_hal_pwr_ex.o stm32f7xx_hal_qspi.o stm32f7xx_hal_rcc.o stm32f7xx_hal_rcc_ex.o stm32f7xx_hal_rng.o stm32f7xx_hal_rtc.o stm32f7xx_hal_rtc_ex.o stm32f7xx_hal_sai.o stm32f7xx_hal_sai_ex.o stm32f7xx_hal_sd.o stm32f7xx_hal_sdram.o stm32f7xx_hal_smartcard.o stm32f7xx_hal_smartcard_ex.o stm32f7xx_hal_spdifrx.o stm32f7xx_hal_spi.o stm32f7xx_hal_sram.o stm32f7xx_hal_tim.o stm32f7xx_hal_tim_ex.o stm32f7xx_hal_uart.o stm32f7xx_hal_usart.o stm32f7xx_hal_wwdg.o stm32f7xx_ll_fmc.o stm32f7xx_ll_sdmmc.o stm32f7xx_ll_usb.o stm_spi_api.o sys.o system_stm32f7xx.o trng_api.o us_ticker.o
  group device
    mbed/TARGET_NUCLEO_F746ZG/TARGET_STM/TARGET_STM32F7/device/: stm32_hal_legacy.h stm32f7xx_hal.h stm32f7xx_hal_adc.h stm32f7xx_hal_adc_ex.h stm32f7xx_hal_can.h stm32f7xx_hal_cec.h stm32f7xx_hal_cortex.h stm32f7xx_hal_crc.h stm32f7xx_hal_crc_ex.h stm32f7xx_hal_cryp.h stm32f7xx_hal_cryp_ex.h stm32f7xx_hal_dac.h stm32f7xx_hal_dac_ex.h stm32f7xx_hal_dcmi.h stm32f7xx_hal_dcmi_ex.h stm32f7xx_hal_def.h stm32f7xx_hal_dfsdm.h stm32f7xx_hal_dma.h stm32f7xx_hal_dma2d.h stm32f7xx_hal_dma_ex.h stm32f7xx_hal_dsi.h stm32f7xx_hal_eth.h stm32f7xx_hal_flash.h stm32f7xx_hal_flash_ex.h stm32f7xx_hal_gpio.h stm32f7xx_hal_gpio_ex.h stm32f7xx_hal_hash.h stm32f7xx_hal_hash_ex.h stm32f7xx_hal_hcd.h stm32f7xx_hal_i2c.h stm32f7xx_hal_i2c_ex.h stm32f7xx_hal_i2s.h stm32f7xx_hal_irda.h stm32f7xx_hal_irda_ex.h stm32f7xx_hal_iwdg.h stm32f7xx_hal_jpeg.h stm32f7xx_hal_lptim.h stm32f7xx_hal_ltdc.h stm32f7xx_hal_ltdc_ex.h stm32f7xx_hal_mdios.h stm32f7xx_hal_nand.h stm32f7xx_hal_nor.h stm32f7xx_hal_pcd.h stm32f7xx_hal_pcd_ex.h stm32f7xx_hal_pwr.h stm32f7xx_hal_pwr_ex.h stm32f7xx_hal_qspi.h stm32f7xx_hal_rcc.h stm32f7xx_hal_rcc_ex.h stm32f7xx_hal_rng.h stm32f7xx_hal_rtc.h stm32f7xx_hal_rtc_ex.h stm32f7xx_hal_sai.h stm32f7xx_hal_sai_ex.h stm32f7xx_hal_sd.h stm32f7xx_hal_sdram.h stm32f7xx_hal_smartcard.h stm32f7xx_hal_smartcard_ex.h stm32f7xx_hal_spdifrx.h stm32f7xx_hal_spi.h stm32f7xx_hal_sram.h stm32f7xx_hal_tim.h stm32f7xx_hal_tim_ex.h stm32f7xx_hal_uart.h stm32f7xx_hal_uart_ex.h stm32f7xx_hal_usart.h stm32f7xx_hal_usart_ex.h stm32f7xx_hal_wwdg.h stm32f7xx_ll_fmc.h stm32f7xx_ll_sdmmc.h stm32f7xx_ll_usb.h
  group drivers
    mbed/drivers/: AnalogIn.h AnalogOut.h BusIn.h BusInOut.h BusOut.h CAN.h DigitalIn.h DigitalInOut.h DigitalOut.h DirHandle.h Ethernet.h FileBase.h FileHandle.h FileLike.h FilePath.h FileSystemLike.h I2C.h I2CSlave.h InterruptIn.h InterruptManager.h LocalFileSystem.h LowPowerTicker.h LowPowerTimeout.h LowPowerTimer.h PortIn.h PortInOut.h PortOut.h PwmOut.h RawSerial.h Serial.h SerialBase.h SPI.h SPISlave.h Stream.h Ticker.h Timeout.h Timer.h TimerEvent.h
  group hal
    mbed/hal/: analogin_api.h analogout_api.h buffer.h can_api.h can_helper.h dma_api.h Driver_Common.h Driver_Storage.h emac_api.h ethernet_api.h gpio_api.h gpio_irq_api.h i2c_api.h lp_ticker_api.h pinmap.h port_api.h pwmout_api.h rtc_api.h serial_api.h sleep_api.h spi_api.h ticker_api.h trng_api.h us_ticker_api.h
  group mbed
    mbed/: mbed.h
  group platform
    mbed/platform/: Callback.h CallChain.h CircularBuffer.h critical.h CThunk.h FunctionPointer.h mbed_assert.h mbed_debug.h mbed_error.h mbed_interface.h mbed_mem_trace.h mbed_stats.h platform.h PlatformMutex.h rtc_time.h semihost_api.h SingletonPtr.h toolchain.h Transaction.h wait_api.h
